# Keil uVision project STM32-DEMO.uvprojx, settings and files
target LED-DEMO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\APP;..\BSP;..\uCOS-III\Cfg;..\uCOS-III\Ports;..\uCOS-III\Source;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\FACE;..\Font;..\HARDWORK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c led.c
  group APP
    ../APP/: app.c conData.c Control.c commom.c 256160.c
  group uC\Source
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC\Ports
    ../uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group uC\LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC\CPU
    ../uCOS-III/uC-CPU/: cpu_core.c cpu_a.asm cpu_c.c
  group uC\Cfg
    ../uCOS-III/Cfg/: os_app_hooks.c
  group Readme
    ../: readme.txt
  group Event
    ../APP/: keyevent.c
software components: CMSIS:CORE 5.0.1
